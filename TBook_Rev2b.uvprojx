# Keil uVision project TBook_Rev2b.uvprojx, settings and files
target TBv2b (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F412VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TBookRev2b +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TBOOKREV2B,STM32F412Vx
  c include: .\Src\inc;.\Src\config;.\Keil\inc;.\Src\Rev2b\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group TBook
    ./Src/: main.c tbook.c tbUtil.c controlmanager.c controlParser.c tknTable.c inputmanager.c ledmanager.c logger.c mediaplayer.c powermanager.c audio.c ak4xxx.c USBD_User_Device_SerNum.c USBD_User_MSC_LUN.c
  group tgtRev2B
    ./Src/Rev2b/: GPIO_STM32F4xx.c I2S_stm32F4xx.c hardfault.s system_stm32f4xx.c
  group config
    ./Src/config/: RTE_Components.h tbRTE_Components.h RTE_Device.h RTX_Config.h EventRecorderConf.h FS_Config_MC_0.h FS_Config_MC_1.h FS_Config_NAND_0.h FS_Config_NOR_0.h USBD_Config_MSC_0.h stm32f4xx_hal_conf.h
    ./Keil/File System/: FS_Config.c FS_Debug.c
    ./Keil/USB/: USBD_Config_0.c USB_Debug.c
  group CMSIS
    ./Keil/CMSIS/: RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c os_systick.c irq_cm4f.s
  group CMSIS Driver
    ./Keil/CMSIS Driver/: AT45DB642D.c
  group Compiler
    ./Keil/Compiler/: EventRecorder.c retarget_io.c
  group STM32F4xx
    ./Keil/STM32F4xx/STM32F412VETx/: startup_stm32f412vx.s stm32f4xx_hal_conf.h
    ./Keil/STM32F4xx/: I2C_STM32F4xx.c MCI_STM32F4xx.c OTG_FS_STM32F4xx.c SPI_STM32F4xx.c USBD_FS_STM32F4xx.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group Keil
    ./Keil/File System/: FS_Dbg_LFN_CM3_L.lib
    ./Keil/USB/: USB_Dbg_CM3_L.lib
software components: CMSIS Driver:NAND:Custom 2.3.0, CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.13.0, File System:Drive:Memory Card 6.13.0, File System:Drive:NAND 6.13.0, File System:Drive:NOR 6.13.0, USB:CORE 6.13.7, USB:Device 6.13.7, USB:Device:MSC 6.13.7, CMSIS Driver:Flash:AT45DB642D 1.3.0, CMSIS Driver:I2C 2.8, CMSIS Driver:MCI 2.8, CMSIS Driver:SPI 2.11, CMSIS Driver:USB Device:Full-speed 2.19, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:QSPI 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:Startup 2.6.2
